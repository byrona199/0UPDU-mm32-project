# Keil uVision project mm32f0131c4q.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MM32F0131C4P MindMotion
  pack: MindMotion.MM32F0130_DFP.1.0.3
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: mm32f0131c4q +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Inc;.\HAL_Lib\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group User
    ./: main.c Thread.c uart_txrx_interrupt.c iwdg.c can.c modbus_meter.c modbus_rtu.c buttons.c ht1621.c pdu_role.c
  group HAL_Lib
    ./HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_can.c hal_comp.c hal_crc.c hal_crs.c hal_dbg.c hal_div.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_rtc.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
software components: CMSIS Driver:I2C:Custom 1.0.0, CMSIS:CORE 5.5.0, CMSIS:RTOS:Keil RTX 4.82.0, Device:Startup 1.0.2
